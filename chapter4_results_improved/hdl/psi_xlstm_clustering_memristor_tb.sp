* SPICE Testbench for Ψ-xLSTM Memristor Model
* Auto-generated by Ψ-xLSTM Framework
* Model: psi_xlstm_clustering

.title Psi-xLSTM Memristor Transient Simulation

* Include Verilog-A module
.hdl ./chapter4_results_improved\hdl\psi_xlstm_clustering_memristor_tb.va

* Power supply
Vdd vdd 0 DC 5.0

* Input voltage source (transient waveform)
Vin p 0 PWL(
+  0ns -1.0V
+  250000.0ns 1.0V
+  500000.0ns -1.0V
+  750000.0ns 1.0V
+  1000000.0ns 0V
+)

* Device under test
X1 p 0 psi_xlstm_clustering_memristor

* Load resistor
Rload p 0 1MEG

* Analysis
.tran 1000.000ns 1000000.0ns

* Output
.print tran v(p) i(Vin)

* Control
.control
run
plot v(p) i(Vin)
wrdata ./chapter4_results_improved\hdl\psi_xlstm_clustering_memristor_tb_results.dat v(p) i(Vin)
quit
.endc

.end
